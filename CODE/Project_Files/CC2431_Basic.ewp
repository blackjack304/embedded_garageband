# IAR project CC2431_Basic.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2431F128.i51
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pe1105
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Drivers\; ..\Interface\; ..\App_Layer\; ..\Common\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2431F128_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
configuration Module_1 (8051, debug)
  as the first configuration, except:
configuration Module_2 (8051, debug)
  as the first configuration, except:
configuration Module_3 (8051, debug)
  as the first configuration, except:
  group (top)
    ../: Project.h
  group App_Layer
    ../App_Layer/: App_RF.c App_RF.h Drum.c Drum.h key_map.c key_map.h Main_mod1.c Main_mod2.c Main_mod3.c piano.c piano.h utilMisc.c utilMisc.h
  group Common
    ../Common/: hal_cc8051.h hal_defs.h hal_types.h
  group Drivers
    ../Drivers/: adc.c adc.h clock.c clock.h graphics_lcd.c graphics_lcd.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_SPI.c hal_SPI.h kb.c kb.h midi.c midi.h mmc2.c mmc2.h scancodes.h uart.c uart.h uart_intfc.c uart_intfc.h
  group Interface
    ../Interface/: basic_rf.c basic_rf.h hal_assert.c hal_assert.h hal_board.c hal_board.h hal_digio.h hal_led.c hal_led.h TimerManager.c TimerManager.h TouchScreen.c TouchScreen.h util.c util.h
